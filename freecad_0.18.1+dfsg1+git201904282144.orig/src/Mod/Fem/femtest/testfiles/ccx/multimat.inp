** written by FreeCAD inp file writer for CalculiX,Abaqus meshes
** highest dimension mesh elements only.

** Nodes
*Node, NSET=Nall
1, 0, 0, 10
2, 0, 0, 20
3, 0, 10, 10
4, 0, 10, 20
5, 10, 0, 10
6, 10, 0, 20
7, 10, 10, 10
8, 10, 10, 20
9, 0, 0, 0
10, 0, 10, 0
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

** Volume elements
*Element, TYPE=C3D10, ELSET=Evolumes
1, 177, 73, 173, 348, 350, 349, 196, 352, 351, 353
2, 148, 177, 173, 348, 355, 196, 354, 356, 352, 353
3, 124, 73, 123, 348, 358, 357, 144, 359, 351, 360
4, 173, 124, 123, 348, 362, 144, 361, 353, 359, 360
5, 73, 77, 148, 348, 97, 363, 364, 351, 365, 356
6, 173, 176, 148, 348, 197, 366, 354, 353, 367, 356
7, 198, 176, 173, 348, 369, 197, 368, 370, 367, 353
8, 175, 198, 173, 348, 371, 368, 195, 372, 370, 353
9, 175, 173, 123, 348, 195, 361, 373, 372, 353, 360
10, 98, 102, 148, 348, 122, 374, 375, 377, 376, 356
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
** Define element set Eall
*ELSET, ELSET=Eall
Evolumes


***********************************************************
** Element sets for materials and FEM element type (solid, shell, beam, fluid)
** written by write_element_sets_material_and_femelement_type function
*ELSET,ELSET=MechanicalMaterialLowSolid
149,
150,
151,
152,
153,
154,
155,
156,
157,
158,
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*ELSET,ELSET=MechanicalMaterialUppSolid
1,
2,
3,
4,
5,
6,
7,
8,
9,
10,
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
***********************************************************
** Node sets for fixed constraint
** written by write_node_sets_constraints_fixed function
** ConstraintFixed
*NSET,NSET=ConstraintFixed
9,
10,
11,
12,
273,
274,
275,
276,
277,
278,
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
***********************************************************
** Materials
** written by write_materials function
** Young's modulus unit is MPa = N/mm2
** FreeCAD material name: Aluminium-Generic
** MechanicalMaterialLow
*MATERIAL, NAME=MechanicalMaterialLow
*ELASTIC
70000, 0.350
** FreeCAD material name: Steel-Generic
** MechanicalMaterialUpp
*MATERIAL, NAME=MechanicalMaterialUpp
*ELASTIC
200000, 0.300

***********************************************************
** Sections
** written by write_femelementsets function
*SOLID SECTION, ELSET=MechanicalMaterialLowSolid, MATERIAL=MechanicalMaterialLow
*SOLID SECTION, ELSET=MechanicalMaterialUppSolid, MATERIAL=MechanicalMaterialUpp

***********************************************************
** At least one step is needed to run an CalculiX analysis of FreeCAD
** written by write_step_begin function
*STEP
*STATIC


***********************************************************
** Fixed Constraints
** written by write_constraints_fixed function
** ConstraintFixed
*BOUNDARY
ConstraintFixed,1
ConstraintFixed,2
ConstraintFixed,3


***********************************************************
** Element + CalculiX face + load in [MPa]
** written by write_constraints_pressure function
** ConstraintPressure
*DLOAD
** ConstraintPressure: face load
61,P3,1000.0
74,P3,1000.0
75,P3,1000.0
80,P2,1000.0
96,P3,1000.0
99,P3,1000.0
100,P4,1000.0
102,P3,1000.0
117,P3,1000.0
118,P3,1000.0
121,P3,1000.0
124,P4,1000.0
127,P2,1000.0
131,P4,1000.0
132,P4,1000.0
134,P2,1000.0

***********************************************************
** Outputs --> frd file
** written by write_outputs_types function
*NODE FILE
U
*EL FILE
S, E

***********************************************************
** written by write_step_end function
*END STEP

***********************************************************
** CalculiX Input file
** written by write_footer function
**   written by    --> FreeCAD 0.17.13310 (Git)
**   written on    --> Tue Feb 20 07:42:43 2018
**   file name     --> multimat.fcstd
**   analysis name --> Analysis
**
**
**
**   Units
**
**   Geometry (mesh data)        --> mm
**   Materials (Young's modulus) --> N/mm2 = MPa
**   Loads (nodal loads)         --> N
**
